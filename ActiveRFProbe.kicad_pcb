# Repository profdc9/ActiveRFProbe

File README.md:

This is an Active RF Probe based on a cheaply available 2SC3356 Bipolar Transistor by Daniel L. Marks, KW4TI.  Dual gate Mosfets are getting hard to find, so this is what I suggest as an alternative RF probe.

The bandwidth is approximately 1 GHz (-3 dB) and the gain at low frequency is 6 dB.

The PCB design is distributed under the Creative Commons Shared Alike Attribution (CC-BY-SA 4.0) license.

## KiCad design ActiveRFProbe.kicad_pcb

Parts:
C1: 100 pF; C_0805_HandSoldering; LCSC C1790
C2, C4, C9: 100 nF; C_0805_HandSoldering; LCSC C49678
C3, C5, C6, C8: 10 nF; C_0805_HandSoldering; LCSC C1710
C16: 22 uF; C_0805_HandSoldering; LCSC C45783
D5: LRB751V; D_SOD-323_HandSoldering; LCSC C131730
D6: LED; LED_0805_HandSoldering; LCSC C2296
J1, J2, J3, J16, J17, J18, J19, J24: Conn_01x01; PadHole
J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J20, J21, J22, J23, J26: Conn_01x01; BigSlot
J25: Conn_Coaxial; Amphenol_RF_SMA_132289
Q1, Q2, Q3: 2SC3356; SOT-23; LCSC C9659
R1, R3, R7: 10R; R_0805_HandSoldering; LCSC C17415
R2, R10: 220R; R_0805_HandSoldering; LCSC C17557
R4, R9: 10k; R_0805_HandSoldering; LCSC C17414
R5, R17, R18: 22R; R_0805_HandSoldering; LCSC C17561
R6: 100R; R_0805_HandSoldering; LCSC C17408
R8, R16: NC; R_0805_HandSoldering
R11, R12: 47k; R_0805_HandSoldering; LCSC C17713
R13: 100k; R_0805_HandSoldering; LCSC C17407
R14: 1k; R_0805_HandSoldering; LCSC C17513
R15: 0R; R_0805_HandSoldering; LCSC C17477

Connections:
+9V: C16.2, D6.2 (A), J2.1, R1.2, R3.2, R7.2
GND: C2.1, C4.2, C8.1, C9.1, C16.1, J16.1, J19.1, J24.1, J25.2 (Ext), R2.2, R5.1, R8.2, R10.2, R13.1, R14.2, R16.2
unnamed: C1.1, R17.2
unnamed: C1.2, J1.1
unnamed: C2.2, Q1.3, R1.1, R11.2
unnamed: C3.1, Q2.1, R4.2
unnamed: C3.2, Q1.2, R2.1
unnamed: C4.1, R3.1, R6.1
unnamed: C5.1, R18.2
unnamed: C5.2, Q2.3, R4.1, R6.2
unnamed: C6.1, R8.1, R15.1
unnamed: C6.2, Q3.2, R9.2, R10.1
unnamed: C8.2, D5.1 (K), J17.1, R13.2
unnamed: C9.2, Q3.3, R7.1, R12.2
unnamed: D5.2 (A), R9.1
unnamed: D6.1 (K), R14.1
unnamed: J3.1, J18.1
unnamed: J25.1 (In), R15.2, R16.1
unnamed: Q1.1, R11.1, R17.1
unnamed: Q2.2, R5.2
unnamed: Q3.1, R12.1, R18.1

Notes on the sheet:
Active RF Probe By D. Marks KW4TI CC-BY-SA 4.0

Board: 2 copper layers, 52.5 x 21.5 mm, 58 parts (0 on the bottom side), 21 nets.

## Commit log

2020-04-19 Oops, this is the first real commit
2020-04-19 Fixed envelope detector
2020-04-20 Made the board smaller
2020-04-20 Changed transistor to 2SC4083
2020-04-20 Version with SOT-232 2SC4083
2020-04-20 Changed transistor to 2SC3357
2020-04-21 Fixed edge detector
2020-04-21 Cleaned up the layout
2020-04-22 Added LCSC parts, fixed symbol, added decoupling resistors
2020-04-23 Changed to 2SC3356
2020-04-29 Added LCSC part numbers, added cutout notched, added series base resistors to emitter followers
2020-05-18 Modified base resistors
